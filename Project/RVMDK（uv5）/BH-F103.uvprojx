# Keil uVision project BH-F103.uvprojx, settings and files
target MODBUS_Master (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MODBUS +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\App;..\..\Bsp;..\..\Ucos-II\Ports;..\..\Ucos-II\Source;..\..\Bsp\font;..\..\Bsp\lcd;..\..\Bsp\led;..\..\Bsp\usart;..\..\Bsp\CRC;..\..\Bsp\Modbus_master;..\..\Bsp\tim;..\..\Bsp\flash;..\..\Bsp\Display;..\..\Bsp\TouchApp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ../../App/: app.c app.h app_cfg.h os_cfg_r.h
  group BSP
    ../../Bsp/: BSP.c BSP.h
    ../../Ucos-II/Ports/: os_cpu.h
    ../../Bsp/font/: fonts.c fonts.h
    ../../Bsp/lcd/: bsp_ili9341_lcd.c bsp_ili9341_lcd.h bsp_xpt2046_lcd.c bsp_xpt2046_lcd.h
    ../../Bsp/led/: bsp_led.c bsp_led.h
    ../../Bsp/usart/: bsp_usart.c bsp_usart.h
    ../../Bsp/CRC/: CRC.c CRC.h
    ../../Bsp/Modbus_master/: Modbus_m.c Modbus_m.h
    ../../Bsp/tim/: bsp_Tim.c bsp_Tim.h
    ../../Bsp/flash/: bsp_spi_flash.c bsp_spi_flash.h
    ../../Bsp/Display/: display.c display.h
    ../../Bsp/TouchApp/: touchapp.c touchapp.h
  group uCOSII/Ports
    ../../Ucos-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group uCOSII/Source
    ../../Ucos-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h includes.h
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DOC
    ../../Doc/: readme.txt
